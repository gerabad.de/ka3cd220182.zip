Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: x:/temp/worker_COMMON_4/temp/tmp_4816_41_y8x3q/format_2/671-1.ifc
Time: 2023-02-15T14:16:22
Made in: PARTsolutions

# IfcProject, 671-1
Description: Cornezza

# IfcDiscreteAccessory, 671-1
In: BUILDING
Description: 671-1
Pset_ManufacturerTypeInformation - Manufacturer: KALDEWEI; ArticleNumber: 671-1
ePset_PARTsolutions - NB: 671-1; NN: Cornezza; NT: Cornezza; NBSYN: $PRODID.; LINA: 671-1; CATALOG: Kaldewei; PRODID: 671-1; DESCRIPTION_SHORT: Shapes that are reduced to the essentials give us a sense of clarity and simplicity. The Cornezza was born out of this thought. Clear lines for pure shower pleasure. Large footprint for plenty of freedom of movement. And floor-level installation for more elegance in the bathroom.; DESCRIPTION_LONG: Pure shower pleasure; EDGE_WIDTH_E5: 65.0; OUTER_LENGTH_A1: 900.0; INSTALLATION_VARIANT_DW: floorlevelsuitable; OUTLETPOSITION: cornerdrain; OUTER_FORM_DW: pentagon; CORNER_OUTER_WIDTH_D2: 945.0; EDGE_HEIGHT_C4: 32.0; WIDTH_ACCESS_AREA_D5: 636.0; LEG_LENGTH_J6: 450.0; CORNER_INNER_LENGTH_D3: 1023.0; OUTER_RADIUS_R1: 23.0; CORNER_OUTER_LENGTH_D1: 1254.0; DISTANCE_BATHEDGE_TO_MID_DRAINHOLE_F2: 190.0; DEPTH_INNER_C1: 65.0; DIAMETER_DRAINHOLE_F9: 90.0; CORNER_INNER_WIDTH_D4: 765.0; OUTER_WIDTH_B1: 900.0; EF000010: Universal; EF000051: Pentagonal; EF020814: true; EF025058: false; EF020363: false; EF002169: -; EF000386: 2,9; EF020621: 23,0; EF001438: 900,0; EF000008: 900,0; EF000040: 32,0; EF001131: 65,0; EF022185: false; EF025073: false; EF025060: false; EF025074: -; EF000007: Beige; EF024897: Glossy; EF025075: false; EF020710: 90,0; EF025068: true; EF025076: false; EF023789: true; EF000139: Enamelled
